# Keil uVision project project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: CW32L031C8 WHXY
  pack: WHXY.CW32L031_DFP.1.0.1
  cpu: IRAM(0x20000000,0x02000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 wLevel=2
  c include: ..\..\..\..\IdeSupport\MDK;..\..\..\..\Libraries\inc;..\USER\inc;..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep=*Handler
  group Startup
    ../../../../IdeSupport/MDK/: startup_cw32l031.s
    ../../../../Libraries/src/: system_cw32l031.c
  group User
    ../USER/src/: main.c interrupts_cw32l031.c
  group Driver
    ../../../../Libraries/src/: cw32l031_atim.c cw32l031_rcc.c cw32l031_gpio.c cw32l031_flash.c cw32l031_adc.c cw32l031_gtim.c cw32l031_uart.c
  group Doc
    ../: readme.txt
  group Utilities
    ../../../../Utilities/: cw32l031cxtx_startkit.c
software components: CMSIS:CORE 5.3.0
