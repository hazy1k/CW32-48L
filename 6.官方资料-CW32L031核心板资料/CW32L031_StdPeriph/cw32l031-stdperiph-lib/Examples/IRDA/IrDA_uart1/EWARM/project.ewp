# IAR project project.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: CW32L031 CW32L031
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\USER\inc; ..\..\..\..\Libraries\inc; ..\..\..\..\IdeSupport\EWARM; ..\..\..\..\Utilities
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.hex
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration debug (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __DEBUG
  ICCARM.CCIncludePath2: ..\USER\inc; ..\..\..\..\Libraries\inc; ..\..\..\..\IdeSupport\EWARM
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\CW\cw32l031.icf
  group Startup
    ../../../../IdeSupport/EWARM/: startup_cw32l031.s
    ../../../../Libraries/src/: system_cw32l031.c
  group User
    ../USER/src/: main.c interrupts_cw32l031.c
  group Driver
    ../../../../Libraries/src/: cw32l031_atim.c cw32l031_rcc.c cw32l031_gpio.c cw32l031_flash.c cw32l031_adc.c cw32l031_gtim.c cw32l031_uart.c
  group Doc
    ../: readme.txt
  group Utilities
    ../../../../Utilities/: cw32l031cxtx_startkit.c
